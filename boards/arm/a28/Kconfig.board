## boards/arm/a28/Kconfig.board
```kconfig
# Copyright (c) 2024 Mysteryassss
# SPDX-License-Identifier: MIT

config BOARD_A28
    bool "a28"
    depends on SOC_NRF52840_QIAA
```
